# Keil uVision project Exercise.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51ED2 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x6FF) CLOCK(33000000) MODP2
  output: Exercise
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 16BITSUBINDDIRECT.asm 8bitsubindirect.asm 8bitadddirect.asm 8bitaddindirect.asm 8BITSUBDIRECT.asm 16BITDIRECT.asm 16BITINDIRECT.asm 16BITSUBDIRECT.asm
