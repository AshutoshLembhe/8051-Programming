# Keil uVision project Register Indirecr addressing mode.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51ED2 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x6FF) CLOCK(33000000) MODP2
  output: Register Indirecr addressing mode
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: indirectloop2.asm
